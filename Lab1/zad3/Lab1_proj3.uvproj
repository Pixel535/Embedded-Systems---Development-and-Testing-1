# Keil uVision project Lab1_proj3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lab1_proj3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: prog3.c
